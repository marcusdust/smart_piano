# Keil uVision project test_2812b.uvproj, settings and files
target test2812 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: test_2812b +hex
  c flags: Optim=1
  c include: .\library\inc;.\interrupt;.\cmsis
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group library
    ./library/src/: stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_systick.c stm32f10x_lib.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_nvic.c stm32f10x_usart.c stm32f10x_tim.c
  group boot
    ./boot/: cortexm3_macro.s stm32f10x_vector.s
  group interrupt
    ./interrupt/: stm32f10x_it.c
  group src
    ./src/: main.c
